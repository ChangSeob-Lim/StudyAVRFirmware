<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DCMotor_PWM2.ewp</path>
  </project>
  <batchBuild />
</workspace>
